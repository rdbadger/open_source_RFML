options:
  parameters:
    author: David Badger
    description: UHF filtering
    generate_options: qt_gui
    id: UHD_B200_fosphor_rev2
    output_language: python
    title: N210 source
  states: {}

blocks:
- name: antenna
  id: variable_qtgui_chooser
  parameters:
    label: Antenna
    label0: '"TX/RX"'
    label1: '"RX2"'
    num_opts: '2'
    option0: '"TX/RX"'
    option1: '"RX2"'
    type: string
    value: '"RX2"'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 444e6
  states: {}
- name: samp
  id: variable
  parameters:
    value: 40e6
  states: {}
- name: fosphor_qt_sink_c_0_0_0
  id: fosphor_qt_sink_c
  parameters:
    freq_center: freq
    freq_span: span
  states: {}
- name: gain
  id: parameter
  parameters:
    type: eng_float
    value: '0'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    size: '1024'
    type: complex
    update_time: update
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp
    fc: freq
    fftsize: '1024'
    grid: 'True'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp
    fc: freq
    fftsize: '1024'
    int_min: '-70'
    showports: 'True'
    type: complex
    update_time: update
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: span
  id: parameter
  parameters:
    type: eng_float
    value: 40e6
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: freq
    clock_rate: '0.0'
    dc_offs_enb0: 'False'
    dev_args: '""'
    gain0: gain
    iq_imbal_enb0: 'False'
    norm_gain0: 'False'
    samp_rate: samp
    sync: sync
    type: fc32
  states: {}

connections:
- [uhd_usrp_source_0_0, '0', fosphor_qt_sink_c_0_0_0, '0']
- [uhd_usrp_source_0_0, '0', qtgui_const_sink_x_0, '0']
- [uhd_usrp_source_0_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
