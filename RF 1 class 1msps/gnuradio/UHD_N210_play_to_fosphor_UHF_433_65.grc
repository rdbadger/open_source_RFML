options:
  parameters:
    author: David Badger
    description: UHF filtering
    generate_options: qt_gui
    id: UHD_B200_fosphor_rev2
    output_language: python
    title: N210 source
  states: {}

blocks:
- name: antenna
  id: variable_qtgui_chooser
  parameters:
    label: Antenna
    label0: '"TX/RX"'
    label1: '"RX2"'
    num_opts: '2'
    option0: '"TX/RX"'
    option1: '"RX2"'
    type: string
    value: '"RX2"'
  states: {}
- name: cf
  id: variable
  parameters:
    value: '15000000'
  states: {}
- name: fft_0
  id: variable_qtgui_range
  parameters:
    label: FFT
    orient: Qt.Horizontal
    rangeType: int
    start: '1024'
    step: '1024'
    stop: '7168'
    value: '1024'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 443.025e6
  states: {}
- name: freq_1
  id: variable_qtgui_range
  parameters:
    label: Freq
    orient: Qt.Horizontal
    start: 100e6
    step: 100e3
    stop: 3000e6
    value: 433.65e6
  states: {}
- name: gain_0
  id: variable_qtgui_range
  parameters:
    label: Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '60'
    value: '3'
  states: {}
- name: hi_0
  id: variable_qtgui_range
  parameters:
    label: hi
    orient: Qt.Horizontal
    start: '-100'
    step: '1'
    stop: '100'
    value: '5'
  states: {}
- name: low_0
  id: variable_qtgui_range
  parameters:
    label: low
    orient: Qt.Horizontal
    start: '-200'
    step: '1'
    stop: '-60'
    value: '-125'
  states: {}
- name: samp_1
  id: variable_qtgui_range
  parameters:
    label: sample_rate
    orient: Qt.Horizontal
    start: 1e6
    step: 1e6
    stop: 50e6
    value: 1e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: samp_rate2
  id: variable
  parameters:
    value: '30000000'
  states: {}
- name: update
  id: variable_qtgui_range
  parameters:
    label: update
    orient: Qt.Horizontal
    start: '.00001'
    step: '.00005'
    stop: '.05'
    value: '.01'
  states: {}
- name: fosphor_qt_sink_c_0_0_0
  id: fosphor_qt_sink_c
  parameters:
    freq_center: freq_1
    freq_span: samp_1
  states: {}
- name: freq_0
  id: parameter
  parameters:
    type: eng_float
    value: 433.65e6
  states: {}
- name: gain
  id: parameter
  parameters:
    type: eng_float
    value: '0'
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"driver=lime,Soapy=0"'
    bb_gain0: '20'
    freq0: cf
    gain0: '20'
    gain_mode0: 'False'
    if_gain0: '20'
    iq_balance_mode0: '2'
    sample_rate: samp_rate2
    sync: sync
    type: fc32
  states: {state: disabled}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    size: '1024'
    type: complex
    update_time: update
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq_1
    fftsize: fft_0
    grid: 'True'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_1
    fc: freq_1
    fftsize: fft_0
    int_max: hi_0
    int_min: low_0
    showports: 'True'
    type: complex
    update_time: update
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: LNAL
    center_freq0: cf
    clock_rate: '0.0'
    dc_offs_enb0: '""'
    dev_addr: '"addr = 1d50:6108"'
    dev_args: '"driver=lime,soapy=0"'
    gain0: '20'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate2
    sync: sync
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: freq_1
    clock_rate: '0.0'
    dc_offs_enb0: 'False'
    dev_args: '""'
    gain0: gain_0
    iq_imbal_enb0: 'False'
    norm_gain0: 'False'
    samp_rate: samp_1
    sync: sync
    type: fc32
  states: {}

connections:
- [uhd_usrp_source_0_0, '0', fosphor_qt_sink_c_0_0_0, '0']
- [uhd_usrp_source_0_0, '0', qtgui_const_sink_x_0, '0']
- [uhd_usrp_source_0_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
