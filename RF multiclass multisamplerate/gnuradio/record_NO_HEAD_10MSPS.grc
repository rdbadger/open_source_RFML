options:
  parameters:
    author: David Badger
    description: ISM Band capture
    generate_options: no_gui
    id: record_live_10msps
    output_language: python
    run_options: run
    title: UHF Band
  states: {}

blocks:
- name: antenna
  id: parameter
  parameters:
    value: '"RX2"'
  states: {}
- name: args
  id: parameter
  parameters:
    value: '""'
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: int(samp_rate*seconds)
    type: complex
  states: {}
- name: filename
  id: parameter
  parameters:
    value: '""'
  states: {}
- name: freq
  id: parameter
  parameters:
    type: eng_float
    value: 433.00e6
  states: {}
- name: gain
  id: parameter
  parameters:
    type: eng_float
    value: '10'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    type: eng_float
    value: 10e6
  states: {}
- name: seconds
  id: parameter
  parameters:
    type: eng_float
    value: '5'
  states: {}
- name: sigmf_sink_0
  id: sigmf_sink
  parameters:
    append: 'False'
    author: David Badger
    description: Filtered
    field_10_key: ''
    field_10_type: string
    field_10_value: ''
    field_11_key: ''
    field_11_type: string
    field_11_value: ''
    field_12_key: ''
    field_12_type: string
    field_12_value: ''
    field_13_key: ''
    field_13_type: string
    field_13_value: ''
    field_14_key: ''
    field_14_type: string
    field_14_value: ''
    field_15_key: ''
    field_15_type: string
    field_15_value: ''
    field_16_key: ''
    field_16_type: string
    field_16_value: ''
    field_17_key: ''
    field_17_type: string
    field_17_value: ''
    field_18_key: ''
    field_18_type: string
    field_18_value: ''
    field_19_key: ''
    field_19_type: string
    field_19_value: ''
    field_1_key: core:hardware
    field_1_type: string
    field_1_value: noise
    field_20_key: ''
    field_20_type: string
    field_20_value: ''
    field_21_key: ''
    field_21_type: string
    field_21_value: ''
    field_22_key: ''
    field_22_type: string
    field_22_value: ''
    field_23_key: ''
    field_23_type: string
    field_23_value: ''
    field_24_key: ''
    field_24_type: string
    field_24_value: ''
    field_25_key: ''
    field_25_type: string
    field_25_value: ''
    field_2_key: core:BW
    field_2_type: string
    field_2_value: none
    field_3_key: core:SNR
    field_3_type: float
    field_3_value: '0'
    field_4_key: core:modulation
    field_4_type: string
    field_4_value: none
    field_5_key: core:DTMF
    field_5_type: string
    field_5_value: NA
    field_6_key: core:class
    field_6_type: string
    field_6_value: '4'
    field_7_key: ''
    field_7_type: string
    field_7_value: ''
    field_8_key: ''
    field_8_type: string
    field_8_value: ''
    field_9_key: ''
    field_9_type: string
    field_9_value: ''
    filename: /home/david/sigMF_ML/RF/ramdisk/test1
    hardware: N210
    license: ''
    num_extra_fields: '6'
    samp_rate: samp_rate
    time_mode: gr_sigmf.sigmf_time_mode_relative
    type: fc32
  states: {}
- name: sigmf_usrp_gps_message_source_1
  id: sigmf_usrp_gps_message_source
  parameters:
    poll_interval: '1.0'
    uhd_args: ''
  states: {state: disabled}
- name: subdev
  id: parameter
  parameters:
    value: '""'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: antenna
    bw0: samp_rate
    center_freq0: freq
    clock_rate: '0.0'
    dc_offs_enb0: 'False'
    dev_args: args
    gain0: gain
    iq_imbal_enb0: 'False'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sd_spec0: subdev
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_head_0, '0', sigmf_sink_0, '0']
- [sigmf_usrp_gps_message_source_1, out, sigmf_sink_0, gps]
- [uhd_usrp_source_0, '0', blocks_head_0, '0']

metadata:
  file_format: 1
